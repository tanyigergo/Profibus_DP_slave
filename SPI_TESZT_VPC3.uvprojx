# Keil uVision project SPI_TESZT_VPC3.uvprojx, settings and files
target STM32F103C8T6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_TESZT_VPC3
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\Firmware\Customer\Inc;.\Firmware\Customer;.\Test
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: Main.c periph_init.c vpc3.c
  group Ext
    ./: delay.c lcd16x2.c
  group Profibus_FW_src
    ./Firmware/Customer/: DpAppl.c DpCfg.c DpDiag.c DpPrm.c
  group Profibus_DP_Driver
    ./Firmware/Customer/DPV0_DRV/: dp_if.c dp_isr.c
  group Test
    ./Test/: test.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
